# Keil uVision project UART.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UART +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\include;.\cmsis;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./src/: stm32f10x_usart.c misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group startup
    ./cmsis/startup/: startup_stm32f10x_hd.s
  group cmsis
    ./cmsis/: core_cm3.c system_stm32f10x.c
  group user
    ./user/: main.c bsp_uart.c stm32f10x_it.c
